Commit message: changed axes orientation

File: ik_module/urdf/2dof_leg_module_v3.urdf (robot description, URDF)
Before this commit: robot 2dof_leg_module_v3, 3 links, 2 joints
Joints:
- joint hip_joint: axis 0 -1 0 -> 0 1 0
